# Keil uVision project ble_app_template.uvprojx, settings and files
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_template +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_NRF6310
  c include: ..;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\s110;..\..\..\..\..\Include\sd_common
  memory RVCT4: ROM 0x16000 size 0x29000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group ::Device
    RTE/Device/nRF51822_xxAA/: arm_startup_nrf51.s system_nrf51.c
    RTE/Device/nRF51822_xxAB/: arm_startup_nrf51.s system_nrf51.c
  group Source Code
    ./../src/: main.c
    ../src/: zes_sns.h zes_spi.c zes_sns.c zes_sys.c zes_sys.h
  group Services
    ./../lib/nrf51822/Source/ble/ble_services/: ble_srv_common.c
    ../lib/nrf51822/Source/ble/ble_services/: ble_bas.c
    ../src/: battery.c ble_sam.c
  group Libraries
    ./../lib/nrf51822/Source/ble/: ble_error_log.c ble_advdata.c ble_conn_params.c ble_debug_assert_handler.c
    ./../lib/nrf51822/Source/app_common/: pstorage.c crc16.c app_scheduler.c app_timer.c app_button.c app_gpiote.c
    ./../lib/nrf51822/Source/sd_common/: softdevice_handler.c
    ../lib/nrf51822/Source/nrf_delay/: nrf_delay.c
  group Zendo
    ../src/: zes_lis3dsh.c zes_lis3dsh.h
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: as above
  output: sensor +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_NRF6310 BOARD_SAM
  c include: ..;..\inc;..\lib\nrf51822\Include;..\lib\nrf51822\Include\app_common;..\lib\nrf51822\Include\ble;..\lib\nrf51822\Include\ble\ble_services;..\lib\nrf51822\Include\s110;..\lib\nrf51822\Include\sd_common;..\lib\nrf51822\Include\boards;..\src;..\lib\nrf51822\Board;..\lib\nrf51822\Board\pca10001;..\lib\nrf51822\Board\pca10001\s110
  memory RVCT4: ROM 0x16000 size 0x9000
  memory RVCT9: RAM 0x20002000 size 0x2000
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
